options:
  parameters:
    category: Custom
    generate_options: qt_gui
    id: radio
    output_language: python
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 1450e3
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: sample_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: 1e6
    fc: center_freq
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [osmosdr_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
